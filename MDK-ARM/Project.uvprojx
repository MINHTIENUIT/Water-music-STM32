# Keil uVision project Project.uvprojx, settings and files
target STM32F4-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO,HAL_UART_MODULE_ENABLED
  c include: ../inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/inc;../../../../../../Drivers/BSP/STM32F4-Discovery;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../../Drivers/BSP/Components/lis302dl/: lis302dl.c
    ../../../../../../Drivers/BSP/Components/lis3dsh/: lis3dsh.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio_dma.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_i2s.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil.lib
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_core.c usbh_ioreq.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_mult_f32.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_q15_to_float.c
    ../../../../../../Drivers/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_rfft_f32.c arm_rfft_init_f32.c arm_bitreversal2.S arm_cfft_radix8_f32.c
  group Application/User
    ../Src/: stm32f4xx_it.c usbh_conf.c waveplayer.c main.c
    ./: TimerPWM.c stm32f4xx_hal_msp.c Utitils.c JsonParse.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/STM32F4-Discovery
    ../../../../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery_audio.c stm32f4_discovery.c stm32f4_discovery_accelerometer.c
software components: CMSIS:CORE 4.3.0
